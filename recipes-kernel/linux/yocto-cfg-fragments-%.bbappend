LINUX-YOCTO_INC_WRLINUX = ""
LINUX-YOCTO_INC_WRLINUX:osv-wrlinux = "linux-yocto-wrlinux.inc"
require ${LINUX-YOCTO_INC_WRLINUX}
